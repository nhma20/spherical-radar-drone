Commit message: markers, pcl combiner, manual offboard mode

File: urdf/test.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- link drone: geometry visual mesh filename=package://spherical-radar-drone/mesh/drone_radar_dome_fine_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
